Commit message: .

File: src/lib/assets/robots/R1/urdf/R1.urdf (robot description, URDF)
Before this commit: robot R1, 40 links, 39 joints
Joints:
- joint head_pitch_joint: type revolute -> fixed
- joint head_yaw_joint: type revolute -> fixed
